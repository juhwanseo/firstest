# Keil uVision project TIMER1n_MatchInterrupt.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x1800) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TIMER1n_MatchInterrupt +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: __NO_EMBEDDED_ASM
  c include: ..\..\..\..\Core\CMSIS\Include;   ..\..\..\..\Core\Device\ABOV\A31G12x\Include;   ..\..\..\..\Drivers\Include;   ..\..\..\..\Examples\TIMER1n\TIMER1n_MatchInterrupt
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Device
    ../../../../Core/Device/ABOV/A31G12x/Source/: system_A31G12x.c
  group Main
    ../../../../Examples/TIMER1n/TIMER1n_MatchInterrupt/: A31G12x_it.c A31G12x_PortInit.c A31G12x_SystemClock.c main.c
    ../: key.c fnd.c
    ./: timer.c
  group Startup
    ../../../../Core/Device/ABOV/A31G12x/Source/ARM/: startup_A31G12x.s
  group Option
    ../../../../Option/KEIL/: option_A31G12x.s
  group Drivers
    ../../../../Drivers/Source/: A31G12x_hal_intc.c A31G12x_hal_pcu.c A31G12x_hal_scu.c A31G12x_hal_timer1n.c A31G12x_hal_uartn.c A31G12x_hal_debug_frmwrk.c
software components: CMSIS:CORE 5.6.0
