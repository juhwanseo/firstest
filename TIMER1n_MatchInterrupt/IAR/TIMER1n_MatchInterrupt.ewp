# IAR project TIMER1n_MatchInterrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: A31G123 ABOV A31G123
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\ABOV\A31G12x\Include; ..\..\..\..\Drivers\Include; ..\..\..\..\Examples\TIMER1n\TIMER1n_MatchInterrupt
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TIMER1n_MatchInterrupt.hex
  ILINK.IlinkOutputFile: TIMER1n_MatchInterrupt.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Device
    ../../../../Core/Device/ABOV/A31G12x/Source/: system_A31G12x.c
  group Drivers
    ../../../../Drivers/Source/: A31G12x_hal_intc.c A31G12x_hal_pcu.c A31G12x_hal_scu.c A31G12x_hal_timer1n.c A31G12x_hal_uartn.c A31G12x_hal_debug_frmwrk.c
  group Main
    ../../../../Examples/TIMER1n/TIMER1n_MatchInterrupt/: A31G12x_it.c A31G12x_PortInit.c A31G12x_SystemClock.c main.c
  group Option
    ../../../../Option/IAR/: option_A31G12x_iar.c
  group Startup
    ../../../../Core/Device/ABOV/A31G12x/Source/IAR/: startup_A31G12x_iar.s
